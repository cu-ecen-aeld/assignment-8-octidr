## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
    bool "ldd kernel modules"
    help
      Builds and installs LDD kernel modules (misc-modules, scull)
```
